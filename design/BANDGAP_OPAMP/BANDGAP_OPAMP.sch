v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 0 0 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 0 500 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 0 300 0 0 {name=p3 lab=PWRUP_1V8}
C {devices/ipin.sym} 0 140 0 0 {name=p4 lab=VIN_P}
C {devices/ipin.sym} 0 210 0 0 {name=p5 lab=VIN_N}
C {devices/opin.sym} 690 180 0 0 {name=p6 lab=VOUT}
