v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 0 -300 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 0 200 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 0 0 0 0 {name=p3 lab=PWRUP_1V8}
C {bandgap_opamp.sym} 340 -70 0 0 {name=x1}
C {devices/opin.sym} 800 -140 0 0 {name=p4 lab=I_PTAT}
C {devices/opin.sym} 800 -20 0 0 {name=p5 lab=V_CTAT}
